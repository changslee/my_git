# Keil uVision project mg.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG2455-F48 RadioPulse
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: mg +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 app_mangled.c
